# Keil uVision project IntelligentGate.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IntelligentGate
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.h main.c RFID.c RFID.h KeyBoard.h KeyBoard.c LCD1602.h LCD1602.c PCF8563.h PCF8563.c Photoelectric.h Photoelectric.c Buzzer.h Buzzer.c DHT11.h DHT11.c FM25CL64.h FM25CL64.c
